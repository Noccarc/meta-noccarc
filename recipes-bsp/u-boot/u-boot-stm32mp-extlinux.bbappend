UBOOT_EXTLINUX_KERNEL_ARGS = "rootwait quiet rw"
