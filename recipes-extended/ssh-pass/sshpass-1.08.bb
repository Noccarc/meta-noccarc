PR = "1.08"

require sshpass.inc

SRC_URI[md5sum] = "25d268df6076fe52c0ec1c294ece2785"
SRC_URI[sha256sum] = "8bdacb8ca4ecf82c84a5effa2f75a8bf4ed9dd6f9d030f308fe11cffb3830b02"
