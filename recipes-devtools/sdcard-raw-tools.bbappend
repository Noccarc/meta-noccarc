FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://001-extend-rootfs-2GB.patch"
