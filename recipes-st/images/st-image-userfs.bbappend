PACKAGE_INSTALL = " \
    hmifiles \
    otafiles \
    zmqfiles \
    m4coredump \
    "
